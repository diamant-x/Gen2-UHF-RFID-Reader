<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhf_rfid_get_epc</value></param>
<param><key>author</key><value>jlejarreta@uoc.edu</value></param>
<param><key>comment</key><value>sudo GR_SCHEDULER=STS nice -n -20 {python} -u {filename}</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>UHF RFID</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_rate</value></param>
<param><key>value</key><value>100e6/50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dac_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>865.7e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_taps</value></param>
<param><key>comment</key><value># Each FM0 symbol consists of ADC_RATE/BLF samples (2e6/40e3 = 50 samples)
# 10 samples per symbol after matched filtering and decimation</value></param>
<param><key>value</key><value>[1]*25</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>print_results</value></param>
<param><key>block_id</key><value>rfid_reader</value></param>
<param><key>function_name</key><value>print_results</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_decoder</value></param>
<param><key>file</key><value>../misc/data/decoder</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_gate</value></param>
<param><key>file</key><value>../misc/data/gate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_matched_filter</value></param>
<param><key>file</key><value>../misc/data/matched_filter</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_reader</value></param>
<param><key>file</key><value>../misc/data/reader</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_source</value></param>
<param><key>file</key><value>../misc/data/source</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>matched_filter</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>num_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>multiply_const_ff</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rfid_gate</key>
<param><key>id</key><value>rfid_gate</value></param>
<param><key>sample_rate</key><value>int(adc_rate/decim)</value></param>
</block>
<block>
<key>rfid_reader</key>
<param><key>id</key><value>rfid_reader</value></param>
<param><key>dac_rate</key><value>int(dac_rate)</value></param>
<param><key>sample_rate</key><value>int(adc_rate/decim)</value></param>
</block>
<block>
<key>rfid_tag_decoder</key>
<param><key>id</key><value>rfid_tag_decoder</value></param>
<param><key>sample_rate</key><value>int(adc_rate/decim)</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>dac_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>False</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>adc_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>uhd_usrp_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>matched_filter</source_block_id><sink_block_id>file_sink_matched_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>matched_filter</source_block_id><sink_block_id>rfid_gate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multiply_const_ff</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>file_sink_gate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>rfid_tag_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>file_sink_reader</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>multiply_const_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>rfid_reader</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>file_sink_decoder</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>file_sink_source</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>matched_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
