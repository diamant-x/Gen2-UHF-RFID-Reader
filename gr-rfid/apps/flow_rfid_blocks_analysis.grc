<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhf_rfid_blocks_analysis</value></param>
<param><key>author</key><value>jlejarreta@uoc.edu</value></param>
<param><key>comment</key><value>sudo GR_SCHEDULER=STS nice -n -20 {python} -u {filename}</value></param>
<param><key>description</key><value>UHF RFID GnuRadio decoder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>UHF RFID GnuRadio decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>GUI_samples</value></param>
<param><key>value</key><value>int(0.7*(44+62+16+62+18+62+96+62)*(adc_rate*24/1000000))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_rate</value></param>
<param><key>comment</key><value>Host Sample Rate (8b/16b) 50/25 MS/s

25e6/32</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ampl</value></param>
<param><key>comment</key><value>This is the maximum amplitude of the 'normalized' wave.
Setting it to be 1 (0dbFS) makes the transmitted wave to behave anormally (sinusoidal instead of flat CW).</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dac_rate</value></param>
<param><key>comment</key><value>Host Sample Rate (8b/16b) 50/25 MS/s</value></param>
<param><key>value</key><value>2*1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>comment</key><value>865.7e6</value></param>
<param><key>value</key><value>865.7e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>maxBandwidthTransmission</value></param>
<param><key>comment</key><value>Bandwidth can't be modified in UBX-40.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>8.75/tari</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>print_results</value></param>
<param><key>block_id</key><value>rfid_reader</value></param>
<param><key>function_name</key><value>print_results</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>18</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain_antenna</value></param>
<param><key>value</key><value>7.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samplerate_rfidblocks</value></param>
<param><key>comment</key><value>This should be based on output of the decimation from the FIR dilter.</value></param>
<param><key>value</key><value>adc_rate/1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fir_averaging_samples</value></param>
<param><key>comment</key><value># Each FM0 symbol consists of ADC_RATE/BLF samples (2e6/40e3 = 50 samples)

# The signal is conditioned for decoding by converting the complex I/Q samplesto amplitude samples, and then passing the signal throughan averaging filter to smooth out noise.</value></param>
<param><key>value</key><value>[1]*25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tari</value></param>
<param><key>comment</key><value>6.3.1.2.4 Tari values
Interrogators shall communicate using Tari values in the range of 6.25μs to 25μs.
Interrogator compliance shall be evaluated using at least one Tari value between 6.25μs and 25μs with at least one value of the parameter x.
The tolerance on all parameters specified in units of Tari shall be +/–1%.
The choice of Tari value and x shall be in accordance with local radio regulations.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>24e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain_antenna</value></param>
<param><key>value</key><value>7.3</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.to_pmt({"gain": -20})</value></param>
<param><key>period</key><value>10000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>360deg/2Pi rad</value></param>
<param><key>const</key><value>57.295779513082320876798154814105</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>comment</key><value>360deg/2Pi rad</value></param>
<param><key>const</key><value>57.295779513082320876798154814105</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>comment</key><value>360deg/2Pi rad</value></param>
<param><key>const</key><value>57.295779513082320876798154814105</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Ettus RX Source Tags</value></param>
</block>
<block>
<key>blocks_tag_share</key>
<param><key>id</key><value>blocks_tag_share_0</value></param>
<param><key>io_type</key><value>complex</value></param>
<param><key>share_type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_decoder</value></param>
<param><key>file</key><value>../misc/data/decoder_complex</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_decoder2</value></param>
<param><key>file</key><value>../misc/data/decoder_float</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_gate</value></param>
<param><key>file</key><value>../misc/data/gate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_matched_filter</value></param>
<param><key>file</key><value>../misc/data/matched_filter</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_reader</value></param>
<param><key>file</key><value>../misc/data/reader</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_reader_0</value></param>
<param><key>file</key><value>../misc/data/file_sink</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_source</value></param>
<param><key>file</key><value>../misc/data/source</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter</value></param>
<param><key>comment</key><value>This block smoothens the signal in time domain to reduce noise effects.</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_fir_averaging_samples</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>gui_tab</value></param>
<param><key>label0</key><value>Source</value></param>
<param><key>label1</key><value>FIR Filter</value></param>
<param><key>label2</key><value>Gate</value></param>
<param><key>label3</key><value>Tag_Decoder</value></param>
<param><key>label4</key><value>Reader</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>multiply_const_ff</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>gui_tab@3 : 1,2,1,1</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>Complex output</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>tr_level</key><value>10.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0</value></param>
<param><key>xmax</key><value>21</value></param>
<param><key>ymax</key><value>1.0</value></param>
<param><key>ymin</key><value>-1.0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@4 : 1,2,1,1</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>Complex output</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>tr_level</key><value>10.0</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-0.1</value></param>
<param><key>ymax</key><value>1.0</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>gui_hint</key><value>gui_tab@0 : 0,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>xmax</key><value>1.1</value></param>
<param><key>xmin</key><value>-0.1</value></param>
<param><key>name</key><value>Normalized magnitude RX</value></param>
<param><key>bins</key><value>200</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@0 : 1,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>Phase</value></param>
<param><key>xmax</key><value>180</value></param>
<param><key>xmin</key><value>-180</value></param>
<param><key>name</key><value>Phase (deg) Histogram</value></param>
<param><key>bins</key><value>360</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@1 : 1,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>Phase</value></param>
<param><key>xmax</key><value>180</value></param>
<param><key>xmin</key><value>-180</value></param>
<param><key>name</key><value>Phase (deg) Histogram</value></param>
<param><key>bins</key><value>360</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@2 : 1,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>Phase</value></param>
<param><key>xmax</key><value>180</value></param>
<param><key>xmin</key><value>-180</value></param>
<param><key>name</key><value>Phase (deg) Histogram</value></param>
<param><key>bins</key><value>360</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>gui_tab@1 : 0,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>xmax</key><value>1.1</value></param>
<param><key>xmin</key><value>-0.1</value></param>
<param><key>name</key><value>Normalized magnitude RX</value></param>
<param><key>bins</key><value>200</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_1_0</value></param>
<param><key>gui_hint</key><value>gui_tab@2 : 0,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>xmax</key><value>1.1</value></param>
<param><key>xmin</key><value>-0.1</value></param>
<param><key>name</key><value>Normalized magnitude RX</value></param>
<param><key>bins</key><value>200</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_2</value></param>
<param><key>gui_hint</key><value>gui_tab@3 : 0,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>xmax</key><value>1.1</value></param>
<param><key>xmin</key><value>-0.1</value></param>
<param><key>name</key><value>Float output</value></param>
<param><key>bins</key><value>20</value></param>
<param><key>size</key><value>16</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_2_0</value></param>
<param><key>gui_hint</key><value>gui_tab@4 : 0,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>xmax</key><value>1.1</value></param>
<param><key>xmin</key><value>-0.1</value></param>
<param><key>name</key><value>Float output</value></param>
<param><key>bins</key><value>20</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@0 : 0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>name</key><value>Amplitude/Magnitude</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@0 : 1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Phase</value></param>
<param><key>alpha2</key><value>0.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Magnitude</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>width2</key><value>0</value></param>
<param><key>name</key><value>Phase Plot</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Phase</value></param>
<param><key>yunit</key><value>deg</value></param>
<param><key>ymax</key><value>180</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@1 : 1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Phase</value></param>
<param><key>alpha2</key><value>0.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Magnitude</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>width2</key><value>0</value></param>
<param><key>name</key><value>Phase Plot</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Phase</value></param>
<param><key>yunit</key><value>deg</value></param>
<param><key>ymax</key><value>180</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>gui_tab@2 : 1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Phase</value></param>
<param><key>alpha2</key><value>0.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Magnitude</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>width2</key><value>0</value></param>
<param><key>alpha3</key><value>0.0</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>alpha4</key><value>0.0</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>Phase Plot</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>int(samplerate_rfidblocks)</value></param>
<param><key>tr_chan</key><value>2</value></param>
<param><key>tr_level</key><value>2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Phase</value></param>
<param><key>yunit</key><value>deg</value></param>
<param><key>ymax</key><value>180</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@1 : 0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>name</key><value>Amplitude/Magnitude</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_level</key><value>2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@2 : 0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>alpha2</key><value>0.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>style2</key><value>0</value></param>
<param><key>width2</key><value>0</value></param>
<param><key>alpha3</key><value>0.0</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>style3</key><value>0</value></param>
<param><key>width3</key><value>0</value></param>
<param><key>alpha4</key><value>0.0</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>style4</key><value>0</value></param>
<param><key>width4</key><value>0</value></param>
<param><key>name</key><value>Amplitude/Magnitude</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>int(samplerate_rfidblocks)</value></param>
<param><key>tr_chan</key><value>2</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@3 : 0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>name</key><value>Float Output</value></param>
<param><key>size</key><value>18</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>bit</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@3 : 1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Complex output</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Bit</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@4 : 1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Complex output</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Bit</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>gui_tab@4 : 0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Magnitude</value></param>
<param><key>name</key><value>Float Output</value></param>
<param><key>size</key><value>GUI_samples</value></param>
<param><key>srate</key><value>adc_rate</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>tr_tag</key><value>"rfid_status"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>bit</value></param>
<param><key>yunit</key><value>?</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>rfid_gate</key>
<param><key>id</key><value>rfid_gate</value></param>
<param><key>comment</key><value>Detects Messages. Detects negative edges (as R-T is PIE encoded).
Outputs: The samples from the Tag replies RN16 and EPC concatenated.</value></param>
<param><key>sample_rate</key><value>int(samplerate_rfidblocks)</value></param>
</block>
<block>
<key>rfid_reader</key>
<param><key>id</key><value>rfid_reader</value></param>
<param><key>dac_rate</key><value>int(dac_rate)</value></param>
<param><key>sample_rate</key><value>int(samplerate_rfidblocks)</value></param>
</block>
<block>
<key>rfid_tag_decoder</key>
<param><key>id</key><value>rfid_tag_decoder</value></param>
<param><key>sample_rate</key><value>int(samplerate_rfidblocks)</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>dac_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>False</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>adc_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>sc16</value></param>
</block>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_tag_share_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>uhd_usrp_source</sink_block_id><source_key>strobe</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>file_sink_reader_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>uhd_usrp_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter</source_block_id><sink_block_id>blocks_complex_to_magphase_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter</source_block_id><sink_block_id>file_sink_matched_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter</source_block_id><sink_block_id>rfid_gate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multiply_const_ff</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>blocks_complex_to_magphase_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>file_sink_gate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rfid_gate</source_block_id><sink_block_id>rfid_tag_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>blocks_tag_share_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>file_sink_reader</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>multiply_const_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_reader</source_block_id><sink_block_id>qtgui_time_sink_x_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>file_sink_decoder2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>qtgui_time_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>rfid_reader</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>file_sink_decoder</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfid_tag_decoder</source_block_id><sink_block_id>qtgui_time_sink_x_0_2_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>blocks_complex_to_magphase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>file_sink_source</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
